# Keil uVision project N32G430xx_FreeRTOS.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: N32G430C8L7 Nationstech
  pack: Nationstech.N32G430_DFP.1.1.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: N32G430xx_0176BY_X +hex
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: N32G430, USE_STDPERIPH_DRIVER
  c misc: --diag_suppress=1,177,550
  c include: .\CMSIS\core;.\CMSIS\device;.\CMSIS\device\startup;.\n32g430_std_periph_driver\inc;.\User\inc;.\FreeRTOS\include;.\FreeRTOS\portable\RVDS\ARM_CM4F;.\FreeRTOS;.\SystemView
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group startup
    ./CMSIS/device/startup/: startup_n32g430.s
  group CMSIS
    ./CMSIS/device/: system_n32g430.c
  group driver
    ./n32g430_std_periph_driver/src/: misc.c n32g430_adc.c n32g430_gpio.c n32g430_beeper.c n32g430_can.c n32g430_comp.c n32g430_crc.c n32g430_dbg.c n32g430_dma.c n32g430_exti.c n32g430_flash.c n32g430_i2c.c n32g430_iwdg.c n32g430_lptim.c n32g430_pwr.c n32g430_rcc.c n32g430_rtc.c n32g430_spi.c n32g430_tim.c n32g430_usart.c n32g430_wwdg.c
  group user
    ./User/src/: main.c n32g430_it.c motor_hall.c ble_module.c key.c remote_control.c fan_heat_massage.c sound_box.c bsp_spi.c
    ./User/inc/: remote_control.h fan_heat_massage.h
  group FreeRTOS
    ./FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group port
    ./FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ./FreeRTOS/portable/MemMang/: heap_4.c
  group systemView
    ./SystemView/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_SYSVIEW.c SEGGER_SYSVIEW_Config_FreeRTOS.c SEGGER_SYSVIEW_FreeRTOS.c
